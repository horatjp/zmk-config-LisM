## app/Kconfig
```kconfig
config ZMK_BEHAVIOR_OS_LAYER
    bool "OS Layer switching based on active BT profile"
    default n
```
